SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2026.1/edf_files/2026.1/04121811/external/packagegroup-openamp-fw-examples/versal-vpk120-multidomain_packagegroup-openamp-fw-examples_04121811.tar.gz"
SRC_URI[sha256sum] = "9e31970057dfc1aa9c748c15ba0bfa482f529d40b5f7a97733a0cd1784ef8c16"

require conf/includes/openamp-fw-example.inc
