SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2026.1/edf_files/2026.1/03110137/external/packagegroup-openamp-fw-examples/versal-vck190-multidomain_packagegroup-openamp-fw-examples_03110137.tar.gz"
SRC_URI[sha256sum] = "7a7e7c4bcd475ef74f3d6e2ae953ad873f34cedda32e20eeb0ba2e39e8ab87ff"

require conf/includes/openamp-fw-example.inc
