SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2026.1/edf_files/2026.1/12190000/external/packagegroup-openamp-fw-examples/versal-vek280-sdt-seg_packagegroup-openamp-fw-examples_12190000.tar.gz"
SRC_URI[sha256sum] = "f7b8b2bc6a93c5318d31f537ba6a9d56409be4e13a114cc139881418ca877431"

require conf/includes/openamp-fw-example.inc
