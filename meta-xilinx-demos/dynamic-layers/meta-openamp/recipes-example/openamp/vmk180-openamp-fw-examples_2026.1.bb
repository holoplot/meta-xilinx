SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2026.1/edf_files/2026.1/04131543/external/packagegroup-openamp-fw-examples/versal-vmk180-multidomain_packagegroup-openamp-fw-examples_04131543.tar.gz"
SRC_URI[sha256sum] = "1bde358154d0556efaf7526cae9358d7f99d2c88158a6e6361cee2680e23068d"

require conf/includes/openamp-fw-example.inc
