SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2026.1/edf_files/2026.1/04151526/external/packagegroup-openamp-fw-examples/versal-vrk165-multidomain_packagegroup-openamp-fw-examples_04151526.tar.gz"
SRC_URI[sha256sum] = "cd554fc5f6d7dcf962c793fa36b566d7da57f59e8c3be14a0391aa3169188879"

require conf/includes/openamp-fw-example.inc
