BASECAMP_IMAGE_FULL_INSTALL:append = " packagegroup-vitis-aiml"
