TOOLCHAIN_TARGET_TASK:append = " packagegroup-vitis-aiml-dev"
TOOLCHAIN_HOST_TASK:append = " nativesdk-packagegroup-vitis-aiml"
