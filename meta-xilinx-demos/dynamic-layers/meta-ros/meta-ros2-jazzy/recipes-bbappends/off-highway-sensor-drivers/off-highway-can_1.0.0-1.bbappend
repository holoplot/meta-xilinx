# Temporary fix for invalid LICENSE field in meta-ros
LICENSE = "Apache-2.0 & MIT"
