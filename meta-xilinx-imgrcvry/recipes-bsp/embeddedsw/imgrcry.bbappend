COMPATIBLE_MACHINE:versal = "versal"
