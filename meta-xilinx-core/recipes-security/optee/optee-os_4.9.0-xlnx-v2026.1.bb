require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.9.0"
SRCREV = "c5dcc5a1aeba164e9bb1e74dd569df0860f7e06e"
