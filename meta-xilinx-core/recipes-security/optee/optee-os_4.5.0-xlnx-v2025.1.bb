require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.5.0"
SRCREV = "7a1c204f7204b34bd4c850ab1b30ddd5df0b36c7"
