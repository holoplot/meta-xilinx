require optee-os-amd.inc

BRANCH = "xlnx_rebase_v4.5.0"
SRCREV = "81198918e8254bf2aefc19e2c8954b42228899aa"
