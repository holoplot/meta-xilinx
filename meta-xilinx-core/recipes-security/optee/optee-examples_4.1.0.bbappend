COMPATIBLE_MACHINE:versal2 = ".*"
