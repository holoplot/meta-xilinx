
require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "ddc9aaefd6d03ace7f52fe1771dd95dd388bfa98"

