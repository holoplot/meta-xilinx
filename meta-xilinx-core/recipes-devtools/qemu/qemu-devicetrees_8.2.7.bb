PE = "1"

require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "e3487555350d2ee993f8947d5a7f3c6d236f6924"

LIC_FILES_CHKSUM = "file://Makefile;beginline=1;endline=28;md5=910f55f350edb281f6a71c45ec27cf2b"
