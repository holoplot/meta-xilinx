
require qemu-devicetrees.inc

BRANCH ?= "master"
SRCREV ?= "15a56d32480b3d69a810fce3183cb9e444e35461"

