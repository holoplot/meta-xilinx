FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://do-not-listen-to-old-udp-prot-listener.patch"
