BRANCH = "xlnx_rel_v2026.1"
SRCREV = "f52abd2ed5a4f3af4512f1b7d5a6512629e1e5aa"

include image-builder.inc
