BRANCH = "xlnx_rel_v2025.2"
SRCREV = "da77e7d09bbdcfd8f10b7d732afd2a7a40166a01"

include image-builder.inc
