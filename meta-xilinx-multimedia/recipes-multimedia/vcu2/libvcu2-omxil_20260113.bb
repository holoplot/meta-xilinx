LIC_FILES_CHKSUM = "file://LICENSE.md;md5=624e7970a65c3e70b309116d8fb6c3d7"

BRANCH ?= "master"
SRCREV = "3a0eaf4e1c5856acedc95ffcfdde6269ccae0d37"

require libvcu2-omxil.inc
